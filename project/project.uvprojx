# Keil uVision project project.uvprojx, settings and files
target project (6240000::V6.24::ARMCLANG)
  device: STM32G431CBTx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00008000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3
  c define: USE_FULL_LL_DRIVER,STM32G431xx
  c include: .;..\CMSIS;..\HardWare;..\LIB\inc;..\USER;.cmsis\include;RTE\_Target 1;..\Math
  asm define: USE_FULL_LL_DRIVER,STM32G431xx
  memory RVCT1: ROM 0x8000000 size 0x10000
  memory RVCT6: RAM 0x20000000 size 0x5000
  group Math
    ../Math/: FOC.c pid.c foc_svpwm.c
  group User
    ../USER/: main.c dshot.c motor_control.c stm32g4xx_it.c
  group HardWare
    ../HardWare/: adc.c comp.c dma.c gpio.c led.c rcc.c tim.c opamp.c dac.c
  group Lib
    ../LIB/src/: stm32g4xx_ll_adc.c stm32g4xx_ll_comp.c stm32g4xx_ll_cordic.c stm32g4xx_ll_crc.c stm32g4xx_ll_crs.c stm32g4xx_ll_dac.c stm32g4xx_ll_dma.c stm32g4xx_ll_exti.c stm32g4xx_ll_fmac.c stm32g4xx_ll_fmc.c stm32g4xx_ll_gpio.c stm32g4xx_ll_hrtim.c stm32g4xx_ll_i2c.c stm32g4xx_ll_lptim.c stm32g4xx_ll_lpuart.c stm32g4xx_ll_opamp.c stm32g4xx_ll_pwr.c stm32g4xx_ll_rcc.c stm32g4xx_ll_rng.c stm32g4xx_ll_rtc.c stm32g4xx_ll_spi.c stm32g4xx_ll_tim.c stm32g4xx_ll_ucpd.c stm32g4xx_ll_usart.c stm32g4xx_ll_usb.c stm32g4xx_ll_utils.c
  group StartUp
    ../StartUp/: startup_stm32g431xx.s
  group CMSIS
    ../CMSIS/: system_stm32g4xx.c
